# Keil uVision project ai8051u_templete.uvproj, settings and files
target code (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(40000000)
  output: ai8051u_templete +hex
  link misc: REMOVEUNUSED
  group user
    ./: main.c board_config.h sys_clock.c sys_clock.h servo_pwm.c servo_pwm.h servo_ctrl.c servo_ctrl.h i2c_slave.c i2c_slave.h
  group library
    ./: set_adc.c set_adc.h set_eeprom.c set_eeprom.h set_io.c set_io.h MDU32_C251.LIB TFPU_C251.LIB
